# Keil uVision project 51-test-new.uvproj, settings and files
target target (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 51-test-new +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c
  group include
    ./: utils.h delay.h font_table.h lcd.h keyboard.h
  group utils
    ./: delay.c font_table.c lcd.c keyboard.c
